Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 17fd9e40-f8b4-48f2-91a3-46a6e8fbae7a, NumberOfSaves: 26], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_Plate_P10.ifc
Time: 2025-06-24T13:13:46
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcMember: Collegamenti strutturali : ROTHOB_Rothoblaas_Plate_P10 : P10300_100x100x312mm
In: 0_Rothoblaas
Type - PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_CarbonSteel_S235_HDG
Type - Generale - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_Plate_P10; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: www.rothoblaas.com/products/fastening/brackets-and-plates/post-bases/p10-p20; Revision: 000; UniClass2015Code: Pr_20_76_64_54; UniClass2015Title: Metal post bases; UniClass2015Version: Products v1.38; Version: 001
Type - Testo - BottomPlate: 80x80x6 mm; TopHoles: 4xØ11; TopPlate: Ø100x6 mm
Type - Vincoli - ModelNumberCode: 300; Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_S235_HDG
Type - Quote - Height_H: 300 mm; Length_L: 100 mm; Width_B: 100 mm
Type - Dati identità - Descrizione: Embedded tubular post base; Nome del tipo: P10300_100x100x312mm; Numero OmniClass: 23.13.23.11.19.13; Produttore: info@rothoblaas.com
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_76_64_54 - Metal post bases; CECode: ETA-10/0422; CETitle: Three-dimensional nailing plate (Post bases for the support of timber columns and posts as load-bearing elements); CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: Embedded tubular post base; DurationUnit: Years; ExpectedLife: 50; Features: Ground joints for timber columns to be embedded in concrete; Finish: Hot dip galvanising; Grade: n/a; GTIN: 8058776179583; Manufacturer: info@rothoblaas.com; Material: S235 Carbon steel with hot galvanising; MinWeight: 1.9 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: P10300; ModelReference: n/a; Name: Plate; Nome famiglia: ROTHOB_Rothoblaas_Plate_P10; NominalHeight: 312 mm; NominalLength: 100 mm; NominalWidth: 100 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 100x100x312 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_MemberCommon - IsExternal: no
Type - Pset_ProductRequirements - Name: Plate; Category: Pr_20_76_64_54 - Metal post bases
Pset_MemberCommon - Reference: P10300_100x100x312mm
Pset_QuantityTakeOff - Reference: P10300_100x100x312mm
BaseQuantities - CrossSectionArea: 0.0585295 m2; NetVolume: 0.000211223 m3; NetSurfaceArea: 0.117059 m2
Vincoli - Host: Livello : 0_Rothoblaas; Livello: 0_Rothoblaas; Livello abaco: 0_Rothoblaas; Quota altimetrica da livello: 0 mm
Fasi - Fase di creazione: Stato di Progetto
Quote - Area: 0.0585295 m2; DepthPosition: 180 mm; DepthPositionCtrl: 180 mm; Volume: 0.000211223 m3
Altro - Famiglia: ROTHOB_Rothoblaas_Plate_P10; Famiglia e tipo: ROTHOB_Rothoblaas_Plate_P10: P10300_100x100x312mm; ID tipo: 334294; Tipo: P10300_100x100x312mm
